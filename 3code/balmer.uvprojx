# Keil uVision project balmer.uvprojx, settings and files
target balmer (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: balmer
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F303xC
  c include: .\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./src/: main.c adc.c calc.c calc_rc.c corrector.c dac.c display_light.c format_print.c hw_config.c hw_pcd8544.c lcd_interface.c mcp6s21.c menu.c number_edit.c pcd8544.c process_measure.c quadrature_encoder.c systick.c usb_commands.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c vbat.c stm32f30x_it.c system_stm32f30x.c
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group STM32F30x_StdPeriph_Driver
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_usart.c stm32f30x_tim.c
  group STM32_USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group inc
    ./inc/: adc.h calc_rc.h corrector.h dac.h format_print.h hw_config.h hw_pcd8544.h lcd_interface.h main.h mcp6s21.h menu.h number_edit.h pcd8544.h platform_config.h process_measure.h stm32f30x_conf.h stm32f30x_it.h usb_commands.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h vbat.h
